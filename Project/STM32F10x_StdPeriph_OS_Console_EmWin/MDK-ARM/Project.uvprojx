# Keil uVision project Project.uvprojx, settings and files
target STM32103VCT6 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103VCT6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\FreeRTOS\Source\include;..\..\..\Libraries\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\Driver\inc;..\..\Console_Cmds\include;..\..\..\Libraries\emWin\Include;..\GUI;..\GUI_Frames;..\Tasks;..\..\Xmodem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../: stm32f10x_it.c main.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group MDK-ARM
    ../: startup_stm32f10x_hd_vl.s
  group Doc
    ./: readme.txt
  group FreeRTOS
    ../../../Libraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Libraries/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../Libraries/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../: FreeRTOSConfig.h
  group Driver
    ../../Driver/src/: cslPrintf.c cslScanf.c cslUSART.c cslConsole.c cslLCD.c cslRTC.c myButton.c myLed.c myBeep.c w25q128.c FlashControl.c
  group ConsoleCmd
    ../../Console_Cmds/: CslConsoleCmd_echo.c CslConsoleCmd_md.c CslConsoleCmd_xflash.c
    ../: cslConsole_Cmd_config.h
  group emWin
    ../../../Libraries/emWin/Lib/ARM/: GUI_CM3_L.lib
    ../GUI/: GUIConf.c GUIConf.h GUIDRV_Template.c LCDConf.c GUI_X_FreeRTOS.c
  group UI
    ../GUI_Frames/: Frames.h Window_MainDLG.c
  group Tasks
    ../Tasks/: Task_UI.c Task_Console.c Task_Control.c Task_Common.c Task_KeyBoard.c
  group XModem
    ../../Xmodem/: xmodem.c crc16.c
software components: CMSIS:CORE 5.0.1
